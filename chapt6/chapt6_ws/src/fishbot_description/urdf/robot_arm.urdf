Commit message: feat: urdf理解

File: chapt6/chapt6_ws/src/fishbot_description/urdf/robot_arm.urdf (robot description, URDF)
Before this commit: robot arm, 1 links, 0 joints
Links:
- link base_link: mass None -> 1; geometry collision box size=0.3 0.3 0.1; visual box size=0.3 0.3 0.1
